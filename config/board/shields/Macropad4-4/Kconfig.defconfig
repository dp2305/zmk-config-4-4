## config/board/shields/Macropad4-4/Kconfig.defconfig
```kconfig
if Shield_Macropad4x4

config ZMK_KEYBOARD_NAME
    default "Macropad4x4"

endif
```
